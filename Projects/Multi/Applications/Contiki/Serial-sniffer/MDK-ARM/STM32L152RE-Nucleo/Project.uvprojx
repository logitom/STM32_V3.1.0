# Keil uVision project Project.uvprojx, settings and files
target S2LP_STM32L152RE_Nucleo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L152ZE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x20013FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Serial-sniffer_l152
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: X_NUCLEO_S2868A1,RADIO_USES_LONG_PREAMBLE=1,MCU_LOW_POWER=0,RADIO_LOW_POWER=0,PROJECT_CONF_H=1,STM32L152xE,USE_USART2,USE_STM32L1XX_NUCLEO,USE_HAL_DRIVER,USE_STDPERIPH_DRIVER,USE_SPIRIT1_DEFAULT,WITH_UIP6=1,IAR_ARM_CM3,CONTIKI=1,UIP_CONF_TCP=1,NETSTACK_CONF_WITH_IPV6,UIP_CONF_IPV6_RPL=1,AUTOSTART_ENABLE,USE_SYSTICK_DELAY,HSE_VALUE=32000000ul,WITH_UIP,NETSTACK_CONF_WITH_IPV6=1,AUTOSTART_ENABLE=1,SERIAL_SNIFFER,PROJECT_CONF_H=\"project-conf.h\",NETSTACK_CONF_WITH_RIME
  c include: ../../Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/STM32L1xx_HAL_Driver/Inc;../../../../../../../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../../../../../../../Drivers/BSP/STM32L1xx_Nucleo;../../../../../../../Drivers/BSP/X-NUCLEO-S2868A1/Inc;../../../../../../../Middlewares/ST/Contiki_STM32_Library;../../../../../../../Middlewares/ST/Contiki_STM32_Library/Inc;../../../../../../../Middlewares/ST/Contiki_STM32_Library/dev;../../../../../../../Drivers/BSP/Components/;../../../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/Inc;../../../../../../../Drivers/BSP/Components/S2LP/S2LP_Util/Inc;../../../../../../../Middlewares/Third_Party/Contiki;../../../../../../../Middlewares/Third_Party/Contiki/core;../../../../../../../Middlewares/Third_Party/Contiki/core/sys;../../../../../../../Middlewares/Third_Party/Contiki/core/net;../../../../../../../Middlewares/Third_Party/Contiki/core/dev;../../../../../../../Middlewares/Third_Party/Contiki/core/net/ip;../../../../../../../Middlewares/Third_Party/Contiki/core/net/ipv6;../../../../../../../Middlewares/Third_Party/Contiki/core/net/llsec;../../../../../../../Middlewares/Third_Party/Contiki/core/net/rpl;../../../../../../../Middlewares/Third_Party/Contiki;../../../../../../../Middlewares/Third_Party/Contiki/core/lib;../../../../../../../Middlewares/Third_Party/Contiki/apps/servreg-hack;../../../../../../../Projects/Multi/Applications/Contiki/Serial-sniffer/Inc;../../../../../../../Projects/Multi/Applications/Contiki/Serial-sniffer/Src/sniffer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group Application/MDK-ARM
    ./: startup_stm32l152xe.s
  group Middlewares/Contiki/core/net/ipv6
    ../../../../../../../Middlewares/Third_Party/Contiki/core/net/ipv6/: uip-ds6.c uip-ds6-route.c uip6.c sicslowpan.c uip-ds6-nbr.c uip-icmp6.c uip-nd6.c
  group Middlewares/Contiki/core/net/llsec
    ../../../../../../../Middlewares/Third_Party/Contiki/core/net/llsec/: nullsec.c ccm-star-packetbuf.c anti-replay.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_flash_ex.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_usart.c stm32l1xx_hal_gpio.c stm32l1xx_hal_spi.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_uart.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_rtc.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_tim.c stm32l1xx_hal_adc.c
  group Drivers/BSP/Components/S2LP/S2LP_Util
    ../../../../../../../Drivers/BSP/Components/S2LP/S2LP_Util/Src/: S2LP_Util.c
  group Middlewares/Contiki/core/net/ip
    ../../../../../../../Middlewares/Third_Party/Contiki/core/net/ip/: udp-socket.c psock.c tcpip.c resolv.c simple-udp.c uip-packetqueue.c uip-nameserver.c tcp-socket.c ip64-addr.c uip-split.c uip-udp-packet.c uip-debug.c uiplib.c
  group Drivers/BSP/Components/SPIRIT1
    ../../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Src/: SPIRIT_Gpio.c SPIRIT_Irq.c SPIRIT_Radio.c SPIRIT_Management.c SPIRIT_Aes.c SPIRIT_Csma.c SPIRIT_General.c SPIRIT_Calibration.c SPIRIT_Commands.c SPIRIT_DirectRF.c SPIRIT_PktBasic.c SPIRIT_LinearFifo.c SPIRIT_PktCommon.c SPIRIT_PktMbus.c SPIRIT_Timer.c SPIRIT_Types.c SPIRIT_Qi.c SPIRIT_PktStack.c
  group Middlewares/Contiki/core/net/rpl
    ../../../../../../../Middlewares/Third_Party/Contiki/core/net/rpl/: rpl-nbr-policy.c rpl-dag.c rpl.c rpl-timers.c rpl-ns.c rpl-icmp6.c rpl-mrhof.c rpl-of0.c rpl-dag-root.c rpl-ext-header.c
  group Middlewares/Contiki/core/lib
    ../../../../../../../Middlewares/Third_Party/Contiki/core/lib/: memb.c list.c sensors.c random.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group Drivers/BSP/X-NUCLEO-IDS01Ax
    ../../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Src/: radio_gpio.c radio_spi.c radio_shield_config.c
  group Middlewares/Contiki/apps/servreg-hack
    ../../../../../../../Middlewares/Third_Party/Contiki/apps/servreg-hack/: servreg-hack.c
  group Example/User/sniffer
    ../../Src/sniffer/: sniffer.c serial-sniffer.c framer-sniffer-802154.c
  group Middlewares/Contiki/core/net/mac
    ../../../../../../../Middlewares/Third_Party/Contiki/core/net/mac/: nullmac.c nullrdc.c framer-nullmac.c csma.c mac-sequence.c nordc.c mac.c framer-802154.c nullrdc-noframer.c frame802154e-ie.c frame802154.c phase.c
  group Drivers/BSP/Components/S2LP/S2LP_Library
    ../../../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/Src/: S2LP_PktBasic.c S2LP_Fifo.c S2LP_PacketHandler.c S2LP_General.c S2LP_PktWMbus.c S2LP_Types.c S2LP_Qi.c S2LP_Timer.c S2LP_Radio.c S2LP_Csma.c S2LP_Gpio.c S2LP_Commands.c S2LP_PktStack.c
  group Example/User
    ../../Src/: main.c cube_hal_l1.c stm32l1xx_hal_msp.c stm32l1xx_it.c
  group Middlewares/Contiki/core/net
    ../../../../../../../Middlewares/Third_Party/Contiki/core/net/: queuebuf.c link-stats.c netstack.c packetbuf.c linkaddr.c nbr-table.c net-debug.c
  group Drivers/BSP/X-NUCLEO-S2868A1
    ../../../../../../../Drivers/BSP/X-NUCLEO-S2868A1/Src/: radio_spi.c radio_eeprom.c radio_gpio.c radio_shield_config.c radio_timer.c
  group Middlewares/Contiki/core/sys
    ../../../../../../../Middlewares/Third_Party/Contiki/core/sys/: ctimer.c stimer.c timer.c procinit.c process.c etimer.c compower.c arg.c energest.c rtimer.c autostart.c
  group Drivers/BSP/STM32L1xx-Nucleo
    ../../../../../../../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
  group Middlewares/Contiki/core/dev
    ../../../../../../../Middlewares/Third_Party/Contiki/core/dev/: slip.c leds.c
  group Middlewares/Contiki_STM32_Library
    ../../../../../../../Middlewares/ST/Contiki_STM32_Library/Src/: node-id.c radio-arch.c uart-msg.c rtimer-arch.c clock.c watchdog.c contiki-st-radio-main.c console.c radio-driver.c
    ../../../../../../../Middlewares/ST/Contiki_STM32_Library/dev/: radio-sensor.c button-sensor.c leds-arch.c
target SPIRIT1_STM32L152RE_Nucleo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L152ZE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: as above
  output: Serial-sniffer_l152
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: X_NUCLEO_IDS01A4,MCU_LOW_POWER=0,RADIO_LOW_POWER=0,PROJECT_CONF_H=1,STM32L152xE,USE_USART2,USE_STM32L1XX_NUCLEO,USE_HAL_DRIVER,HSE_VALUE=84000000ul,USE_STDPERIPH_DRIVER,USE_SPIRIT1_DEFAULT,WITH_UIP6=1,IAR_ARM_CM3,VECT_TAB_FLASH,WITH_UIP,WITH_ASCII,CONTIKI=1,UIP_CONF_TCP=1,NETSTACK_CONF_WITH_IPV6=1,UIP_CONF_IPV6_RPL=1,AUTOSTART_ENABLE=1,NO_EEPROM,SPIRIT1_ST_SHIELD				,SPIRIT_MODULE,AUTOSTART_ENABLE,SERIAL_SNIFFER
  c include: ../../Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../../../../../../../Drivers/STM32L1xx_HAL_Driver/Inc;../../../../../../../Drivers/BSP/STM32L1xx_Nucleo;../../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Inc;../../../../../../../Middlewares/ST/Contiki_STM32_Library;../../../../../../../Middlewares/ST/Contiki_STM32_Library/Inc;../../../../../../../Middlewares/ST/Contiki_STM32_Library/dev;../../../../../../../Drivers/BSP/Components/;../../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Inc;../../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Util/Inc;../../../../../../../Middlewares/Third_Party/Contiki;../../../../../../../Middlewares/Third_Party/Contiki/core;../../../../../../../Middlewares/Third_Party/Contiki/core/sys;../../../../../../../Middlewares/Third_Party/Contiki/core/net;../../../../../../../Middlewares/Third_Party/Contiki/core/dev;../../../../../../../Middlewares/Third_Party/Contiki/core/net/ip;../../../../../../../Middlewares/Third_Party/Contiki/core/net/ipv6;../../../../../../../Middlewares/Third_Party/Contiki/core/net/llsec;../../../../../../../Middlewares/Third_Party/Contiki/core/net/rpl;../../../../../../../Middlewares/Third_Party/Contiki;../../../../../../../Middlewares/Third_Party/Contiki/core/lib;../../../../../../../Middlewares/Third_Party/Contiki/apps/servreg-hack;../../../../../../../Projects/Multi/Applications/Contiki/Serial-sniffer/Inc;../../../../../../../Projects/Multi/Applications/Contiki/Serial-sniffer/Src/sniffer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
software components: CMSIS:CORE 4.3.0
